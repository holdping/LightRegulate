# Keil uVision project test1.uvprojx, settings and files
target test (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\USER;.\CORE;.\FWLib\inc;.\HARDWARE\sys;.\HARDWARE\delay;.\HARDWARE\LED;.\HARDWARE\lcd1602;.\HARDWARE\sensor;.\HARDWARE\sensor\inc;.\HARDWARE\SR50;.\HARDWARE\BEEP;.\HARDWARE\esp8266;.\HARDWARE\MyUSART;.\HARDWARE\usart3;.\HARDWARE\timer
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ./FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./HARDWARE/sys/: sys.c
  group HARDWARE
    ./HARDWARE/delay/: delay.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/sensor/src/: bsp_adc.c bsp_adc_dma.c
    ./HARDWARE/esp8266/: esp.c
    ./HARDWARE/usart3/: usart3.c
    ./HARDWARE/timer/: Timer.c
